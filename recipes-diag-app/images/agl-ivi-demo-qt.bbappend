IMAGE_INSTALL:append = " diag-app"